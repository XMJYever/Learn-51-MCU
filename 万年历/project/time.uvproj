# Keil uVision project time.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: time +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFiles
    ../source/: Lcd1602.c DS18B20.c DS1302.c Key_Buzzer.c
  group IncludeFiles
    ../source/: config.h DS1302.h Lcd1602.h DS18B20.h Key_Buzzer.h app.h
